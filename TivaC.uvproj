# Keil uVision project TivaC.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: TM4C123GH6PM Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: TivaC
  c flags: Optim=1
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group APPLICATION
    ./: startup_TM4C123.s main.c
  group INCLUDES
    ./inc/: Clock.h GPIO.h GPIO_CNFG.h GPIO_PRIVATE.h LCD.h SEVEN_SEGMENT_DISPLAY.h STD_TYPES.h tm4c123gh6pm.h UART.h UART_CNFG.h UARTINIT.h
  group SOURCES
    ./: Clock.c GPIO.c SEVEN_SEGMENT_DISPLAY.c LCD.c UART.c UARTINIT.c
